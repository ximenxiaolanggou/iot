# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\uart;.\esp8266;.\DELAY;.\LCD;.\mqtt;.\timer0;.\DS18B20;.\OneWire
  group Source Group 1
    ./: main.c
  group uart
    ./uart/: uart.c
  group esp8266
    ./esp8266/: esp8266.c
  group delay
    ./DELAY/: DELAY.c
  group LCD
    ./LCD/: LCD1602.c
  group mqtt
    ./mqtt/: mqtt.c
  group timer0
    ./timer0/: timer_0.c
  group DS18B20
    ./DS18B20/: DS18B20.c
  group OneWire
    ./OneWire/: OneWire.c
