# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD;.\MATRIX;.\DELAY;.\USART;.\DS1302;.\I2C;.\AT24C02;.\TIMER0;.\XPT2046
  group Source Group 1
    ./: main.c
  group LCD
    ./LCD/: LCD1602.c
  group MATRIX
    ./MATRIX/: MATRIX.c
  group DELAY
    ./DELAY/: DELAY.c
  group USART
    ./USART/: USART.c
  group DS1302
    ./DS1302/: DS1302.c
  group I2C
    ./I2C/: I2C.c
  group AT24C02
    ./AT24C02/: AT24C02.c
  group TIMER0
    ./TIMER0/: Timer0.c
  group XPT2046
    ./XPT2046/: XPT2046.c
