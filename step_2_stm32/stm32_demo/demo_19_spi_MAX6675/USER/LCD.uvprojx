# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\TSENSOR;..\HARDWARE\MYDMA;..\HARDWARE\DMA_ADC;..\HARDWARE\IIC;..\HARDWARE\IIC_AT24C02;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\MAX6675
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TSENSOR/: tsensor.c
    ../HARDWARE/MYDMA/: mydma.c
    ../HARDWARE/DMA_ADC/: dma_adc.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/IIC_AT24C02/: at24c02.c
    ../HARDWARE/SPI/: spi1.c
    ../HARDWARE/W25QXX/: w25q64.c
    ../HARDWARE/MAX6675/: max6675.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_spi.c
  group README
    ../: README.TXT
